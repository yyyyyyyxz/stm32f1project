# Keil uVision project Led.uvprojx, settings and files
target Templete (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Led +hex (library)
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xB
  c include: ..\..\Drives\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drives\CMSIS\Include;..\..\Drives\STM32F1xx_HAL_Driver\Inc;..\..\Drives;..\..\Drives\BSP;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Drives/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group User
    ../../User/: main.c init.c stm32f1xx_it.c
    ../../Drives/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/BSP
    ../../Drives/BSP/LED/: led.c
    ../../Drives/BSP/KEY/: key.c
    ../../Drives/BSP/USART/: usart.c
    ../../Drives/BSP/OLED/: oled.c oled_font.c
  group Drivers/SYSTEM
    ../../Drives/SYSTEM/delay/: delay.c
    ../../Drives/SYSTEM/sys/: sys.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drives/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c
